FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-Exit-on-load-failure-when-supervised.patch"
